# IAR project sai.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/codec/wm8960; ../../../../../components/codec; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../middleware/sdmmc/port; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/sdmmc/port; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/io; ../../../../../devices/MIMXRT1062/utilities/log; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../middleware/fatfs/source; ../../../../../middleware/sdmmc/inc; ../../../../../middleware/sdmmc/src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: sai.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/codec/wm8960; ../../../../../components/codec; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../middleware/sdmmc/port; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/sdmmc/port; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../middleware/fatfs/source; ../../../../../middleware/sdmmc/inc; ../../../../../middleware/sdmmc/src
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SKIP_SYSCLK_INIT; DEBUG; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; SKIP_SYSCLK_INIT; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h mpu_armv7.h mpu_armv8.h
  group codec
    ../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../components/codec/wm8960/: fsl_wm8960.c fsl_wm8960.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_usdhc.c fsl_usdhc.h
  group fatfs/fatfs_include
    ../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h
  group fatfs/fatfs_source
    ../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc/port
    ../../../../../middleware/sdmmc/port/usdhc/interrupt/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group source
    ../: ffconf.h playbackSineWave.c recordPlayback.c recordtoSdcard.c sai.c sai.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1062/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h evkmimxrt1060_sdram_ini_dcd.c evkmimxrt1060_sdram_ini_dcd.h
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
