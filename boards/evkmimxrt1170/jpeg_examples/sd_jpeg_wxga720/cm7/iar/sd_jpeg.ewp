# IAR project sd_jpeg.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../..; ..; ../../../../../../middleware/sdmmc/port; ../../../../../src/jpeg_examples/sd_jpeg; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../platform/drivers/cache/armv7-m7; ../../../../../../components/video/display/dc/elcdif; ../../../../../../components/video/display/dc/lcdifv2; ../../../../../../platform/drivers/mipi_dsi; ../../../../../../components/video/display/rm68191; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../platform/drivers/igpio; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../platform/drivers/usdhc; ../../../../../../middleware/libjpeg/inc; ../../../../../../middleware/sdmmc/port; ../../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../../middleware/sdmmc/port; ../../../../../../components/video; ../../../../../../components/video/display/dc; ../../../../../../platform/drivers/common; ../../../../../../devices/MIMXRT1176; ../../../../../../platform/utilities/debug_console/str; ../../../../../../platform/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../platform/drivers/lpuart; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../platform/drivers/elcdif; ../../../../../../components/video/display; ../../../../../../platform/drivers/lcdifv2; ../../../../../../middleware/sdmmc/inc; ../../../../../../middleware/sdmmc/src; ../../../../../../middleware/fatfs/source; ../../../../../../platform/utilities/misc_utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: sd_jpeg.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x20000
  ILINK.IlinkIcfFile: ../../../../../../devices/MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT1176xxxxx_cm7 NXP MIMXRT1176xxxxx_cm7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  ILINK.IlinkIcfFile: ../../../../../../devices/MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT1176xxxxx_cm7 NXP MIMXRT1176xxxxx_cm7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT1176xxxxx_cm7 NXP MIMXRT1176xxxxx_cm7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: as above
  group board
    ../../../../: board.c board.h clock_config.c clock_config.h display_support.c display_support.h
    ../../: pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm7.h mpu_armv7.h mpu_armv8.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_anatop.c fsl_anatop.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_iomuxc.h
    ../../../../../../platform/drivers/cache/armv7-m7/: fsl_cache.c fsl_cache.h
    ../../../../../../platform/drivers/common/: fsl_common.c fsl_common.h
    ../../../../../../platform/drivers/elcdif/: fsl_elcdif.c fsl_elcdif.h
    ../../../../../../platform/drivers/igpio/: fsl_gpio.c fsl_gpio.h
    ../../../../../../platform/drivers/lcdifv2/: fsl_lcdifv2.c fsl_lcdifv2.h
    ../../../../../../platform/drivers/lpuart/: fsl_lpuart.c fsl_lpuart.h
    ../../../../../../platform/drivers/mipi_dsi/: fsl_mipi_dsi.c fsl_mipi_dsi.h
    ../../../../../../platform/drivers/usdhc/: fsl_usdhc.c fsl_usdhc.h
  group evkmimxrt1170/jpeg_examples/sd_jpeg/cm7
    ../: app.h hardware_init.c
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group libjpeg/inc
    ../../../../../../middleware/libjpeg/inc/: cderror.h cdjpeg.h jdct.h jerror.h jinclude.h jmemsys.h jmorecfg.h jpegint.h jpeglib.h jversion.h transupp.h
  group libjpeg/src
    ../../../../../../middleware/libjpeg/src/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc/port
    ../../../../../../middleware/sdmmc/port/usdhc/interrupt/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
  group sdmmc/src
    ../../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group source
    ../../../../../src/jpeg_examples/sd_jpeg/: ffconf.h jconfig.h sd_jpeg.c
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../../../../../platform/utilities/assert/: fsl_assert.c
    ../../../../../../platform/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../platform/utilities/debug_console/str/: fsl_str.c fsl_str.h
  group video
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.c fsl_rm68191.h
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.c fsl_rm68200.h
    ../../../../../../components/video/: fsl_video_common.c fsl_video_common.h
  group xip
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h evkmimxrt1170_sdram_ini_dcd.c evkmimxrt1170_sdram_ini_dcd.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
