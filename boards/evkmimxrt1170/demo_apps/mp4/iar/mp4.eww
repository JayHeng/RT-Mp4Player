<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\mp4.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>sd_jpeg</project>
                <configuration>flexspi_nor_debug</configuration>
            </member>
            <member>
                <project>sd_jpeg</project>
                <configuration>flexspi_nor_release</configuration>
            </member>
            <member>
                <project>sd_jpeg</project>
                <configuration>sdram_debug</configuration>
            </member>
            <member>
                <project>sd_jpeg</project>
                <configuration>sdram_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flexspi_nor_debug</name>
            <member>
                <project>sd_jpeg</project>
                <configuration>flexspi_nor_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flexspi_nor_release</name>
            <member>
                <project>sd_jpeg</project>
                <configuration>flexspi_nor_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>sdram_debug</name>
            <member>
                <project>sd_jpeg</project>
                <configuration>sdram_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>sdram_release</name>
            <member>
                <project>sd_jpeg</project>
                <configuration>sdram_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
