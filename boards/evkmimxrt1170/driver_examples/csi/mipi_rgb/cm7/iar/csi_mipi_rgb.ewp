# IAR project csi_mipi_rgb.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxxx_cm7 NXP MIMXRT1176xxxxx_cm7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1176DVMAA_cm7; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../..; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../components/video/camera/device/sccb; ../../../../../../../components/video/camera/device/ov5640; ../../../../../../../components/video/display/dc/lcdifv2; ../../../../../../../components/video/display; ../../../../../../../components/video/display/rm68191; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../../components/video/display/rm68200; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../components/video/camera/receiver/csi; ../../../../../../../components/video/camera; ../../../../../../../components/video; ../../../../../../../components/video/camera/device; ../../../../../../../components/video/camera/receiver; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../components/video/display/dc; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176; ../../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/serial_manager; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/xip; ../../../../../xip; ../../../../../xip; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: csi_mipi_rgb.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; CPU_MIMXRT1176DVMAA_cm7; SDK_I2C_BASED_COMPONENT_USED=1
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1176DVMAA_cm7; SDK_I2C_BASED_COMPONENT_USED=1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; SDK_I2C_BASED_COMPONENT_USED=1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  group source
    ../: csi_mipi_rgb.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../../../../: display_support.h display_support.c camera_support.h camera_support.c
  group doc
    ../: readme.txt
  group video
    ../../../../../../../components/video/camera/device/sccb/: fsl_sccb.c fsl_sccb.h
    ../../../../../../../components/video/camera/device/ov5640/: fsl_ov5640.c fsl_ov5640.h
    ../../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h
    ../../../../../../../components/video/display/: fsl_display.h
    ../../../../../../../components/video/display/rm68191/: fsl_rm68191.c fsl_rm68191.h
    ../../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h
    ../../../../../../../components/video/display/rm68200/: fsl_rm68200.c fsl_rm68200.h
    ../../../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h
    ../../../../../../../components/video/camera/: fsl_camera.h
    ../../../../../../../components/video/: fsl_video_common.c fsl_video_common.h
    ../../../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../../../components/video/display/dc/: fsl_dc_fb.h
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_gpio.c fsl_gpio.h fsl_csi.c fsl_csi.h fsl_lpi2c.c fsl_lpi2c.h fsl_mipi_csi2rx.c fsl_mipi_csi2rx.h fsl_pxp.c fsl_pxp.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_anatop.c fsl_anatop.h fsl_lcdifv2.c fsl_lcdifv2.h
  group device
    ../../../../../../../devices/MIMXRT1176/: MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h fsl_device_registers.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h evkmimxrt1170_sdram_ini_dcd.c evkmimxrt1170_sdram_ini_dcd.h
