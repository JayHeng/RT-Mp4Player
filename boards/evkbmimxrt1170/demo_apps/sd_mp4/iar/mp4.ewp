# IAR project mp4.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm7; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; BOARD_USE_CODEC=1; SD_ENABLED
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../devices/MIMXRT1176/drivers; ../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../devices/MIMXRT1176; ../../../../../devices/MIMXRT1176/utilities/str; ../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../devices/MIMXRT1176/utilities; ../../../../../devices/MIMXRT1176/xip; ../../../../../middleware/libjpeg/inc; ../../../../../middleware/sdmmc/sd; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/sdmmc/osa; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../middleware/fatfs/source; ../../../../../middleware/ffmpeg/compat; ../../../../../middleware/ffmpeg/libavcodec; ../../../../../middleware/ffmpeg/libavutil; ../../../../../middleware/ffmpeg/libavformat; ../../../../../middleware/ffmpeg; ../../../../../components/osa; ../../../../../components/lists; ../../../../../components/codec; ../../../../../components/codec/i2c; ../../../../../components/codec/port; ../../../../../components/codec/wm8960; ../../../../../components/serial_manager; ../../../../../components/uart; ../../../../../components/i2c; ../../../../../components/video; ../../../../../components/video/display; ../../../../../components/video/display/dc; ../../../../../components/video/display/dc/elcdif; ../../../../../components/video/display/dc/lcdifv2; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/mipi_dsi_cmd
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: mp4.srec
  ILINK.IlinkOutputFile: mp4.out
  ILINK.IlinkConfigDefines: __stack_size__=0x8000; __heap_size__=0x1000000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: RELEASE; CPU_MIMXRT1176DVMAA_cm7; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; BOARD_USE_CODEC=1; SD_ENABLED
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexram_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Core/Include; ../../../../../devices; ..; ../../..; ../../../../../devices/MIMXRT1176/drivers; ../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../devices/MIMXRT1176; ../../../../../devices/MIMXRT1176/utilities/str; ../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../devices/MIMXRT1176/utilities; ../../../../../devices/MIMXRT1176/xip; ../../../../../middleware/libjpeg/inc; ../../../../../middleware/sdmmc/sd; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/sdmmc/osa; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../middleware/fatfs/source; ../../../../../middleware/ffmpeg/compat; ../../../../../middleware/ffmpeg/libavcodec; ../../../../../middleware/ffmpeg/libavutil; ../../../../../middleware/ffmpeg/libavformat; ../../../../../middleware/ffmpeg; ../../../../../components/osa; ../../../../../components/lists; ../../../../../components/codec; ../../../../../components/codec/i2c; ../../../../../components/codec/port; ../../../../../components/codec/wm8960; ../../../../../components/serial_manager; ../../../../../components/uart; ../../../../../components/i2c; ../../../../../components/gpio; ../../../../../components/video; ../../../../../components/video/display; ../../../../../components/video/display/dc; ../../../../../components/video/display/dc/elcdif; ../../../../../components/video/display/dc/lcdifv2; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/hx8394; ../../../../../components/video/display/mipi_dsi_cmd
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexram256i256d1536o_sdram.icf
configuration flexram_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: RELEASE; CPU_MIMXRT1062DVL6A; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; BOARD_USE_CODEC=1
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../devices/MIMXRT1062/utilities; ../../../../../devices/MIMXRT1062/xip; ../../../../../middleware/libjpeg/inc; ../../../../../middleware/sdmmc/src; ../../../../../middleware/sdmmc/inc; ../../../../../middleware/sdmmc/port; ../../../../../middleware/sdmmc/port/interrupt; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../middleware/fatfs/source; ../../../../../middleware/ffmpeg/compat; ../../../../../middleware/ffmpeg/libavcodec; ../../../../../middleware/ffmpeg/libavutil; ../../../../../middleware/ffmpeg/libavformat; ../../../../../middleware/ffmpeg; ../../../../../components/codec; ../../../../../components/codec/i2c; ../../../../../components/codec/port; ../../../../../components/codec/wm8960; ../../../../../components/serial_manager; ../../../../../components/uart; ../../../../../components/i2c
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexram128i128d768o_sdram.icf
configuration flexspinor_sdram_debug (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: mp4.bin
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
configuration flexspinor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: RELEASE; CPU_MIMXRT1062DVL6A; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; BOARD_USE_CODEC=1; FLASH_TYPE_HYPER=1
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspinor_sdram.icf
configuration flexspinor_flexram_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1062DVL6A; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; BOARD_USE_CODEC=1; RECONFIG_FLEXRAM_512KB_ITCM=1; FLASH_TYPE_HYPER=1; SD_ENABLED
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspinor_flexram512i512o_sdram.icf
configuration flexspinor_flexram_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: RELEASE; CPU_MIMXRT1062DVL6A; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; BOARD_USE_CODEC=1; RECONFIG_FLEXRAM_512KB_ITCM=1; FLASH_TYPE_HYPER=1
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: as above
configuration opt_level0_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm7; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; BOARD_USE_CODEC=1; MP4_LCD_BUFFER_OCRAM=1; SD_ENABLED
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_opt_level0.icf
configuration opt_level0_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_opt_level0.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h display_support.c display_support.h pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h
  group component/codec
    ../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
  group component/codec/i2c
    ../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
  group component/codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h
  group component/codec/wm8960
    ../../../../../components/codec/wm8960/: fsl_wm8960.c fsl_wm8960.h
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group component/video
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h
    ../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/hx8394/: fsl_hx8394.c fsl_hx8394.h
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h
    ../../../../../components/video/display/rm68191/: fsl_rm68191.c fsl_rm68191.h
    ../../../../../components/video/display/rm68200/: fsl_rm68200.c fsl_rm68200.h
    ../../../../../components/video/: fsl_video_common.c fsl_video_common.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_pmu.c fsl_pmu.h fsl_pxp.c fsl_pxp.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_usdhc.c fsl_usdhc.h
    ../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group middleware/fatfs/fatfs_include
    ../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h
  group middleware/fatfs/fatfs_source
    ../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
  group middleware/ffmpeg
    ../../../../../middleware/ffmpeg/: config.h
  group middleware/ffmpeg/compat
    ../../../../../middleware/ffmpeg/compat/: va_copy.h
  group middleware/ffmpeg/libavcodec
    ../../../../../middleware/ffmpeg/libavcodec/: aac.h aac_ac3_parser.h aac_defines.h aacadtsdec.c aacadtsdec.h aacdec.c aacdectab.h aacps.h aacps_float.c aacps_tablegen.h aacpsdsp.h aacpsdsp_float.c aacsbr.c aacsbr.h aacsbr_tablegen.h aacsbr_tablegen_common.h aacsbrdata.h aactab.c aactab.h ac3.h ac3tab.c ac3tab.h audioconvert.c audioconvert.h avcodec.h avdct.c avdct.h avfft.c avfft.h avpacket.c avpicture.c bitstream.c bitstream_filter.c blockdsp.h bytestream.h cabac.c cabac.h cabac_functions.h cbrt_tablegen.h codec_desc.c copy_block.h d3d11va.c d3d11va.h dct.h dirac.c dirac.h dv_profile.c dv_profile.h dv_profile_internal.h dxva2.h error_resilience.c error_resilience.h faandct.c faandct.h faanidct.c faanidct.h fdctdsp.c fdctdsp.h fft-internal.h fft.h fft_fixed.c fft_fixed_32.c fft_float.c fft_init_table.c fft_table.h frame_thread_encoder.h get_bits.h golomb.c golomb.h h263dsp.h h264.c h264.h h264_cabac.c h264_cavlc.c h264_direct.c h264_loopfilter.c h264_mb.c h264_mvpred.h h264_picture.c h264_ps.c h264_refs.c h264_sei.c h264_slice.c h264chroma.c h264chroma.h h264data.h h264dsp.c h264dsp.h h264idct.c h264idct.h h264pred.c h264pred.h h264qpel.c h264qpel.h hpeldsp.h idctdsp.c idctdsp.h imdct15.c imdct15.h imgconvert.c internal.h jfdctfst.c jfdctint.c jrevdct.c kbdwin.c kbdwin.h lpc.h mathops.h mathtables.c mdct_fixed.c mdct_fixed_32.c mdct_float.c me_cmp.c me_cmp.h motion_est.h mpeg12data.h mpeg4audio.c mpeg4audio.h mpeg4video.h mpegaudiodata.c mpegaudiodata.h mpegpicture.h mpegutils.h mpegvideo.h mpegvideodsp.h mpegvideoencdsp.h options_codec.c options_table.h opus.h parser.c parser.h pel_template.c pixblockdsp.c pixblockdsp.h pixels.h profiles.c profiles.h put_bits.h qpeldsp.h qsv.h qsv_api.c ratecontrol.h raw.c raw.h rdft.h rectangle.h resample.c resample2.c rl.h rnd_avg.h sbr.h sbrdsp.c sbrdsp.h simple_idct.c simple_idct.h sinewin.c sinewin.h sinewin_fixed.c sinewin_tablegen.h startcode.c startcode.h svq3.h thread.h utils_codec.c vaapi.h vda.h vdpau.h vdpau_compat.h version.h videodsp.c videodsp.h videotoolbox.h vorbis_parser.c vorbis_parser.h vorbis_parser_internal.h xiph.c xiph.h xvididct.h xvmc.h
  group middleware/ffmpeg/libavformat
    ../../../../../middleware/ffmpeg/libavformat/: audiointerleave.h avc.h avformat.h avio.c avio.h avio_internal.h aviobuf.c cutils.c dump.c dv.h file.c format.c hevc.h id3v1.c id3v1.h id3v2.c id3v2.h internal.h isom.c isom.h metadata.c metadata.h mov.c mov_chan.c mov_chan.h mux.c options.c options_table.h os_support.c os_support.h qtpalette.c qtpalette.h rdt.h replaygain.c replaygain.h riff.c riff.h riffdec.c rtp.h rtpdec.h sdp.c srtp.h url.c url.h utilsformat.c version.h
  group middleware/ffmpeg/libavutil
    ../../../../../middleware/ffmpeg/libavutil/: adler32.c adler32.h aes.c aes.h aes_ctr.c aes_ctr.h aes_internal.h atomic.c atomic.h atomic_gcc.h attributes.h audio_fifo.c audio_fifo.h avassert.h avconfig.h avstring.c avstring.h avutil.h base64.c base64.h blowfish.c blowfish.h bprint.c bprint.h bswap.h buffer.c buffer.h buffer_internal.h camellia.c camellia.h cast5.c cast5.h channel_layout.c channel_layout.h colorspace.h common.h cpu.h cpu_internal.h crc.c crc.h des.c des.h dict.c dict.h display.c display.h downmix_info.c downmix_info.h dynarray.h error.c error.h eval.c eval.h ffmath.h ffversion.h fifo.c fifo.h file.h file_open.c fixed_dsp.c fixed_dsp.h float_dsp.c float_dsp.h frame.c frame.h hash.c hash.h hwcontext.h hwcontext_internal.h imgutils.c imgutils.h integer.c integer.h internal.h intfloat.h intmath.c intmath.h intreadwrite.h lfg.c lfg.h libm.h lls.c lls.h log.c log.h log2_tab.c macros.h mastering_display_metadata.c mastering_display_metadata.h mathematics.c mathematics.h md5.c md5.h mem.c mem.h mem_internal.h motion_vector.h murmur3.c murmur3.h opt.c opt.h parseutils.c parseutils.h pixdesc.c pixdesc.h pixelutils.c pixelutils.h pixfmt.h qsort.h random_seed.c random_seed.h rational.c rational.h rc4.c rc4.h replaygain.h reverse.c ripemd.c ripemd.h samplefmt.c samplefmt.h sha.c sha.h sha512.c sha512.h softfloat.h softfloat_tables.h stereo3d.c stereo3d.h tea.c tea.h thread.h threadmessage.c threadmessage.h time.c time.h time_internal.h timecode.c timecode.h timer.h timestamp.h utils.c version.h
  group middleware/sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h
  group middleware/sdmmc/inc
    ../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group middleware/sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group middleware/sdmmc/src
    ../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group source
    ../: ffconf.h mp4.h mp4_gpt_timer.c mp4_lcd_video.c mp4_main.c mp4_sai_audio.c music.h wav.c
  group startup
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
    ../../../../../devices/MIMXRT1176/: system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group xip
    ../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h evkmimxrt1170_sdram_ini_dcd.c evkmimxrt1170_sdram_ini_dcd.h
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
